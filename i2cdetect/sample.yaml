## i2cdetect/sample.yaml
```yaml
sample:
  name: I2C Detect
tests:
  test:
    platform_whitelist: bbc_microbit

    tags: drivers
    depends_on: i2c
```
